# Keil uVision project stm32_project.uvprojx, settings and files
target xianya (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\system_code\CMSIS;..\system_code\stdPeriph_Driver\inc;..\system_code\FreeRTOS\Source\CMSIS_RTOS;..\system_code\FreeRTOS\Source\include;..\system_code\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\user_code\app_code\inc;..\user_code\driver_code\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_System_file
    ../system_code/CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STM32_FWlib_code
    ../system_code/stdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRtos_file
    ../system_code/FreeRTOS/Source/: timers.c tasks.c croutine.c event_groups.c list.c queue.c
    ../system_code/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../system_code/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../system_code/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group user_driver
    ../user_code/driver_code/src/: systick.c xy_usart.c xy_key.c
  group user_app
    ../user_code/app_code/src/: main.c xy_config.c freertos.c xy_usart1_task.c
